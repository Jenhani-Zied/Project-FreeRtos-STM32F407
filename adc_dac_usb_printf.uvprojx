# Keil uVision project adc_dac_usb_printf.uvprojx, settings and files
target ADC_DAC_USB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_dac_usb_printf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_USB_OTG_FS,STM32F4XX,USE_STDPERIPH_DRIVER,
  c include: .\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\USB\inc;.\Libraries;..\vcp_ADC_DAC_printf_USB_khaled;.\Libraries\CMSIS\Include;..\vcp_ADC_DAC_printf_USB_khaled_OK
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group systeme
    ./: startup_stm32f4xx.s stm32f4xx_it.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: system_stm32f4xx.c
  group USB
    ./USB/src/: usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_core.c usbd_ioreq.c usbd_req.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c usb_core.c
  group user
    ./: Config.c main.c stm32f4_discovery.c
  group librairie
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c
